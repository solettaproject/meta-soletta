SRC_URI = "npm://registry.npmjs.org;name=${PN};version=${PV}"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=e273de0d9430b4e4a74446f00e19ac54"

inherit npm
